options:
  parameters:
    generate_options: qt_gui
    id: fpv_tx
    output_language: python
    title: fpv_tx
  states: {}

blocks:
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: fec_k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: fec_poly_list
    rate: '2'
    state_start: '0'
  states: {}
- name: center_freq
  id: variable_config
  parameters:
    config_file: common.ini
    option: center_freq
    section: main
    type: int
    value: '2420000000'
    writeback: None
  states: {}
- name: excess_bw
  id: variable_config
  parameters:
    config_file: common.ini
    option: excess_bw
    section: main
    type: real
    value: '0.35'
    writeback: None
  states: {}
- name: fec_enabled
  id: variable_config
  parameters:
    config_file: common.ini
    option: fec_enabled
    section: main
    type: int
    value: '1'
    writeback: None
  states: {}
- name: fec_k
  id: variable_config
  parameters:
    config_file: common.ini
    option: fec_k
    section: main
    type: int
    value: '7'
    writeback: None
  states: {}
- name: fec_poly_list
  id: variable
  parameters:
    value: '[int(p) for p in fec_polys.split('','')]'
  states: {}
- name: fec_polys
  id: variable_config
  parameters:
    config_file: common.ini
    option: '''fec_polys'''
    section: main
    type: string
    value: 79,109
    writeback: None
  states: {}
- name: log_period_s
  id: variable_config
  parameters:
    config_file: tx.ini
    option: log_period_s
    section: main
    type: real
    value: '1'
    writeback: None
  states: {}
- name: max_latency_ms
  id: variable_config
  parameters:
    config_file: tx.ini
    option: max_latency_ms
    section: main
    type: real
    value: '40'
    writeback: None
  states: {}
- name: mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: '''Modulation'''
    type: string
    value: modulation_text
  states: {}
- name: modulation_text
  id: variable
  parameters:
    value: ('QPSK + CC 1/2, K=%d' % fec_k) if fec_enabled else 'QPSK, FEC off'
  states: {}
- name: pluto_uri
  id: variable_config
  parameters:
    config_file: tx.ini
    option: '''pluto_uri'''
    section: main
    type: string
    value: ip:192.168.3.1
    writeback: None
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rf_bandwidth
  id: variable_config
  parameters:
    config_file: tx.ini
    option: rf_bandwidth
    section: main
    type: int
    value: '2000000'
    writeback: None
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: common.ini
    option: samp_rate
    section: main
    type: int
    value: '2000000'
    writeback: None
  states: {}
- name: samples_per_frame
  id: variable
  parameters:
    value: (188*ts_per_frame + 35) * 8 * (2 if fec_enabled else 1) / 2.0 * sps
  states: {}
- name: sps
  id: variable_config
  parameters:
    config_file: common.ini
    option: sps
    section: main
    type: int
    value: '2'
    writeback: None
  states: {}
- name: ts_per_frame
  id: variable_config
  parameters:
    config_file: common.ini
    option: ts_per_frame
    section: main
    type: int
    value: '4'
    writeback: None
  states: {}
- name: tx_att_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '''TX attenuation, dB'''
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: tx_attenuation_cfg
  states: {}
- name: tx_attenuation_cfg
  id: variable_config
  parameters:
    config_file: tx.ini
    option: tx_attenuation
    section: main
    type: real
    value: '30'
    writeback: None
  states: {}
- name: tx_consumed
  id: variable_function_probe
  parameters:
    block_id: pluto_tx
    function_args: '0'
    function_name: nitems_read
    poll_rate: '100'
    value: '0'
  states: {}
- name: tx_level
  id: variable_config
  parameters:
    config_file: tx.ini
    option: tx_level
    section: main
    type: real
    value: '0.5'
    writeback: None
  states: {}
- name: udp_in_port
  id: variable_config
  parameters:
    config_file: tx.ini
    option: udp_in_port
    section: main
    type: int
    value: '5000'
    writeback: None
  states: {}
- name: fec_encoder
  id: fec_extended_encoder
  parameters:
    encoder_list: cc_encoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: link_monitor
  id: snippet
  parameters:
    code: |
      # Writes the settings and, once per log period, the state of the transmitter
      # to tx.log. The values are only read from the blocks, nothing is changed.
      import logging
      import threading
      import time

      log = logging.getLogger("fpv_tx")
      log.info(
          "settings: center_freq=%d samp_rate=%d sps=%d excess_bw=%.2f ts_per_frame=%d "
          "fec_enabled=%d fec_k=%d fec_polys=%s pluto_uri=%s rf_bandwidth=%d "
          "tx_attenuation=%.2f tx_level=%.2f max_latency_ms=%.0f log_period_s=%.1f",
          self.center_freq, self.samp_rate, self.sps, self.excess_bw, self.ts_per_frame,
          self.fec_enabled, self.fec_k, self.fec_polys, self.pluto_uri, self.rf_bandwidth,
          self.tx_att_slider, self.tx_level, self.max_latency_ms, self.log_period_s,
      )

      def report_loop():
          packetizer = self.packetizer
          totals = packetizer.get_totals()
          samples = self.pluto_tx.nitems_read(0)
          last_time = time.monotonic()
          # stopped is set when the flow graph stops, which ends this thread.
          while not packetizer.stopped.wait(self.log_period_s):
              now = time.monotonic()
              elapsed = now - last_time
              last_time = now
              previous, previous_samples = totals, samples
              totals = packetizer.get_totals()
              samples = self.pluto_tx.nitems_read(0)
              log.info(
                  "status: samples=%.3f data_frames=%d idle_frames=%d input_kbit=%.0f "
                  "queue_bytes=%d dropped_bytes=%d waiting_ms=%.0f tx_attenuation=%.2f",
                  (samples - previous_samples) / (elapsed * self.samp_rate),
                  totals["data_frames"] - previous["data_frames"],
                  totals["idle_frames"] - previous["idle_frames"],
                  (totals["input_bytes"] - previous["input_bytes"]) * 8 / elapsed / 1000.0,
                  totals["queue_bytes"],
                  totals["dropped_bytes"] - previous["dropped_bytes"],
                  totals["waiting_ms"],
                  self.tx_att_slider,
              )

      if self.log_period_s > 0:
          threading.Thread(target=report_loop, daemon=True).start()
    section: main_after_start
  states: {}
- name: pluto_watchdog
  id: snippet
  parameters:
    code: |-
      # Ends the program when the Pluto stops taking samples (it was unplugged or
      # restarted after a power dip). Without this the flow graph waits forever;
      # tx_modem_loop.sh starts it again once the Pluto is back.
      import logging
      import os
      import threading
      import time

      def pluto_watchdog(timeout_s=5.0):
          log = logging.getLogger("fpv_tx")
          last = self.pluto_tx.nitems_read(0)
          since = time.monotonic()
          while not self.packetizer.stopped.wait(0.5):
              now = self.pluto_tx.nitems_read(0)
              if now != last:
                  last, since = now, time.monotonic()
              elif time.monotonic() - since > timeout_s:
                  log.error("Pluto takes no samples for %.0f s, exiting", timeout_s)
                  logging.shutdown()
                  os._exit(3)

      threading.Thread(target=pluto_watchdog, daemon=True).start()
    priority: '1'
    section: main_after_start
  states: {}
- name: packetizer
  id: epy_block
  parameters:
    _source_code: |
      """
      FPV Packetizer (source block).

      Reads MPEG-TS bytes from a UDP port and produces a continuous stream of
      link frames:

          [ sync 32 bit | length 16 bit | length 16 bit | seq 16 bit | type 8 bit | IV 128 bit | AES-CTR(payload + CRC32) | CRC32 ]
                                                        |<------------ whitened ------------>|

      - sync:    fixed word, marks the start of a frame;
      - length:  number of bytes after the header, sent twice (the receiver uses it
                 to reject false sync hits);
      - seq:     frame counter, lets the receiver count lost frames;
      - type:    1 = video data, 0 = idle frame;
      - payload: ts_per_frame MPEG-TS packets (188 bytes each);
      - CRC32:   over seq, type and payload.

      Idle frames are sent when there is no video data, so the RF signal stays
      continuous and the receiver loops stay locked.

      Latency control: GNU Radio buffers would happily store seconds of frames
      between this block and the radio. To avoid that, the block is told how many
      samples the radio has already taken (consumed_samples, updated by a Function
      Probe) and only produces a new frame while less than max_latency_ms of
      signal is waiting in the transmit chain.
      """

      import logging
      import os
      import socket
      import threading
      import time
      import zlib

      import numpy as np
      from gnuradio import gr
      # BEGIN embedded modem_crypto.py
      """AES-128-CTR adapted from the supplied OFDM TX/RX embedded blocks.

      Runs inside GNU Radio packetizer/depacketizer, not in the video applications.
      CRC detects accidental damage/wrong keys; CTR is NOT authenticated encryption.
      No replay protection. Both endpoints must use the same embedded key.
      """
      import os
      import zlib
      from Crypto.Cipher import AES

      # Shared secret: keep this module private. Change on both endpoints together.
      KEY = bytes.fromhex("14ddcf63d5b3cc389d4017aee0e9c562")
      CRYPTO_OVERHEAD = 16 + 4  # transmitted counter block + encrypted payload CRC32
      FRAME_OVERHEAD = 15 + CRYPTO_OVERHEAD


      class FrameCipher:
          def __init__(self, key=KEY):
              if len(key) != 16:
                  raise ValueError("AES-128 requires exactly 16 key bytes")
              self.key = key
              self.nonce = os.urandom(12)
              self.counter = 0

          def encrypt(self, payload):
              plain = payload + zlib.crc32(payload).to_bytes(4, "big")
              blocks = (len(plain) + 15) // 16
              if self.counter + blocks > 2**32:
                  raise OverflowError("AES counter exhausted; restart TX for a fresh nonce")
              iv = self.nonce + self.counter.to_bytes(4, "big")
              cipher = AES.new(self.key, AES.MODE_CTR, nonce=self.nonce,
                               initial_value=self.counter)
              self.counter += blocks  # no overlapping counter ranges between frames
              return iv + cipher.encrypt(plain)

          def decrypt(self, record):
              if len(record) < CRYPTO_OVERHEAD:
                  raise ValueError("Truncated AES frame")
              iv = record[:16]
              cipher = AES.new(self.key, AES.MODE_CTR, nonce=iv[:12],
                               initial_value=int.from_bytes(iv[12:], "big"))
              plain = cipher.decrypt(record[16:])
              if zlib.crc32(plain[:-4]).to_bytes(4, "big") != plain[-4:]:
                  raise ValueError("AES plaintext CRC mismatch (wrong key or damaged frame)")
              return plain[:-4]

      # END embedded modem_crypto.py

      # Log files go to logs/<yyyy-mm-dd>/ in the repository root (next to src), one
      # folder per day. video_common.py and tx_modem_loop.sh use the same place.
      def log_path(name):
          folder = os.path.join(os.path.dirname(os.path.dirname(os.path.abspath(__file__))),
                                "logs", time.strftime("%Y-%m-%d"))
          os.makedirs(folder, exist_ok=True)
          return os.path.join(folder, name)


      TS_PACKET_LEN = 188
      SYNC_WORD = bytes([0xE1, 0x5A, 0xE8, 0x93])
      FRAME_TYPE_IDLE = 0
      FRAME_TYPE_DATA = 1
      # MPEG-TS null packet (PID 0x1FFF); players ignore it.
      TS_NULL_PACKET = bytes([0x47, 0x1F, 0xFF, 0x10]) + bytes([0xFF]) * 184
      # Queue limit in frames. At ~1 Mbit/s 64 frames is about 0.4 s of video.
      MAX_QUEUE_FRAMES = 64
      # Data that does not fill a whole frame is padded and sent after this time.
      MAX_PARTIAL_WAIT_S = 0.02
      # How long the consumed_samples value may be extrapolated without an update.
      MAX_EXTRAPOLATION_S = 0.1
      # Longest time work() waits for the radio before producing a frame anyway.
      MAX_WAIT_S = 0.2


      def whitening_sequence(length):
          """Pseudo-random bytes from the LFSR x^7 + x^4 + 1, all-ones start."""
          state = 0x7F
          out = bytearray(length)
          for i in range(length):
              value = 0
              for _ in range(8):
                  bit = ((state >> 6) ^ (state >> 3)) & 1
                  state = ((state << 1) | bit) & 0x7F
                  value = (value << 1) | bit
              out[i] = value
          return np.frombuffer(bytes(out), dtype=np.uint8)


      class blk(gr.sync_block):
          def __init__(self, udp_port=5000, ts_per_frame=4, log_file="tx.log",
                       samples_per_frame=0.0, samp_rate=2000000, max_latency_ms=40.0,
                       consumed_samples=0):
              gr.sync_block.__init__(
                  self, name="FPV Packetizer + AES-128 TX", in_sig=None, out_sig=[np.uint8]
              )
              self.udp_port = int(udp_port)
              self.payload_len = TS_PACKET_LEN * int(ts_per_frame)
              self.body_len = 3 + self.payload_len + CRYPTO_OVERHEAD + 4
              self._cipher = FrameCipher()
              self.log_file = log_file
              # samples_per_frame = 0 switches the latency control off.
              self.samples_per_frame = float(samples_per_frame)
              self.samp_rate = float(samp_rate)
              self.max_latency_ms = float(max_latency_ms)

              length = bytes([self.body_len >> 8, self.body_len & 0xFF])
              self._header = SYNC_WORD + length + length
              self._whitening = whitening_sequence(self.body_len)
              self._idle_payload = bytes(self.payload_len)
              self._lock = threading.Lock()
              self._consumed = 0
              self._consumed_time = time.monotonic()
              self._sock = None
              self._log = logging.getLogger("fpv_tx")
              self._queue = bytearray()
              self._queue_time = None
              self._pending = b""
              self._seq = 0
              self._frames = 0
              self._dropped_bytes = 0
              self._data_frames = 0
              self._idle_frames = 0
              self._input_bytes = 0
              # Set while the flow graph is not running; ends the status thread.
              self.stopped = threading.Event()
              self.stopped.set()

          @property
          def consumed_samples(self):
              return self._consumed

          @consumed_samples.setter
          def consumed_samples(self, value):
              with self._lock:
                  if value != self._consumed:
                      self._consumed = value
                      self._consumed_time = time.monotonic()

          # The socket and the log are opened in start(), not in __init__, because
          # GNU Radio Companion creates the block once just to inspect its ports.
          def start(self):
              self._log.setLevel(logging.INFO)
              if self.log_file and not self._log.handlers:
                  handler = logging.FileHandler(log_path(self.log_file))
                  handler.setFormatter(logging.Formatter("%(asctime)s %(levelname)s %(message)s"))
                  self._log.addHandler(handler)

              self._sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self._sock.setsockopt(socket.SOL_SOCKET, socket.SO_RCVBUF, 1 << 20)
              self._sock.bind(("0.0.0.0", self.udp_port))
              self._sock.setblocking(False)
              self._log.info(
                  "start: udp_port=%d frame_bytes=%d payload_bytes=%d max_latency_ms=%.0f",
                  self.udp_port, len(self._header) + self.body_len, self.payload_len,
                  self.max_latency_ms,
              )
              self._log.info("AES-128-CTR enabled in modem; crypto overhead %d bytes/frame", CRYPTO_OVERHEAD)
              self.stopped.clear()
              return True

          def stop(self):
              self.stopped.set()
              if self._sock is not None:
                  self._sock.close()
                  self._sock = None
              self._log.info(
                  "stop: data_frames=%d idle_frames=%d dropped_bytes=%d",
                  self._data_frames, self._idle_frames, self._dropped_bytes,
              )
              for handler in list(self._log.handlers):
                  handler.close()
                  self._log.removeHandler(handler)
              return True

          def get_data_frames(self):
              return self._data_frames

          def get_idle_frames(self):
              return self._idle_frames

          def get_dropped_bytes(self):
              return self._dropped_bytes

          def get_totals(self):
              """Counters since the start, for the status line in the log."""
              with self._lock:
                  consumed = self._consumed
              waiting = self._frames * self.samples_per_frame - consumed
              return dict(
                  data_frames=self._data_frames,
                  idle_frames=self._idle_frames,
                  input_bytes=self._input_bytes,
                  dropped_bytes=self._dropped_bytes,
                  queue_bytes=len(self._queue),
                  waiting_ms=waiting / self.samp_rate * 1000.0,
              )

          def _read_socket(self):
              while True:
                  try:
                      data = self._sock.recv(65536)
                  except OSError:
                      break
                  if not self._queue:
                      self._queue_time = time.monotonic()
                  self._queue += data
                  self._input_bytes += len(data)
              # Input is faster than the radio link: drop the oldest TS packets,
              # whole packets only, so the stream stays aligned to 188 bytes.
              limit = self.payload_len * MAX_QUEUE_FRAMES
              if len(self._queue) > limit:
                  excess = len(self._queue) - limit
                  excess += (-excess) % TS_PACKET_LEN
                  del self._queue[:excess]
                  if self._dropped_bytes == 0:
                      self._log.warning("input queue overflow, dropping oldest data")
                  self._dropped_bytes += excess

          def _may_start_frame(self):
              if self.samples_per_frame <= 0:
                  return True
              with self._lock:
                  since_update = min(time.monotonic() - self._consumed_time, MAX_EXTRAPOLATION_S)
                  consumed = self._consumed + since_update * self.samp_rate
              waiting = self._frames * self.samples_per_frame - consumed
              return waiting < self.max_latency_ms * 1e-3 * self.samp_rate

          def _take_payload(self):
              """Returns the payload of the next data frame, or None for an idle frame."""
              now = time.monotonic()
              if len(self._queue) >= self.payload_len:
                  payload = bytes(self._queue[:self.payload_len])
                  del self._queue[:self.payload_len]
                  self._queue_time = now
                  return payload
              whole = len(self._queue) - len(self._queue) % TS_PACKET_LEN
              if whole and now - self._queue_time > MAX_PARTIAL_WAIT_S:
                  # Do not let the last packets of a burst wait for more data.
                  payload = bytes(self._queue[:whole])
                  del self._queue[:whole]
                  self._queue_time = now
                  missing = (self.payload_len - whole) // TS_PACKET_LEN
                  return payload + TS_NULL_PACKET * missing
              return None

          def _next_frame(self):
              payload = self._take_payload()
              if payload is None:
                  frame_type = FRAME_TYPE_IDLE
                  payload = self._idle_payload
                  self._idle_frames += 1
              else:
                  frame_type = FRAME_TYPE_DATA
                  self._data_frames += 1
              encrypted = self._cipher.encrypt(payload)
              body = bytes([self._seq >> 8, self._seq & 0xFF, frame_type]) + encrypted
              body += zlib.crc32(body).to_bytes(4, "big")
              self._seq = (self._seq + 1) & 0xFFFF
              self._frames += 1
              whitened = np.frombuffer(body, dtype=np.uint8) ^ self._whitening
              return self._header + whitened.tobytes()

          def work(self, input_items, output_items):
              out = output_items[0]
              produced = 0
              while produced < len(out):
                  if not self._pending:
                      if not self._may_start_frame():
                          if produced > 0:
                              break
                          self._wait_for_room()
                      self._read_socket()
                      self._pending = self._next_frame()
                  count = min(len(out) - produced, len(self._pending))
                  out[produced:produced + count] = np.frombuffer(
                      self._pending, dtype=np.uint8, count=count
                  )
                  self._pending = self._pending[count:]
                  produced += count
              return produced

          def _wait_for_room(self):
              # A source block must never return zero items (GNU Radio would treat
              # it as finished), so wait here until the radio has taken enough
              # samples. The timeout keeps the flow graph responsive to stop().
              deadline = time.monotonic() + MAX_WAIT_S
              while not self._may_start_frame() and time.monotonic() < deadline:
                  time.sleep(0.001)
    consumed_samples: tx_consumed
    log_file: '''tx.log'''
    max_latency_ms: max_latency_ms
    samp_rate: samp_rate
    samples_per_frame: samples_per_frame
    ts_per_frame: ts_per_frame
    udp_port: udp_in_port
  states: {}
- name: pluto_tx
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att_slider
    bandwidth: rf_bandwidth
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: center_freq
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: qpsk_mod
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: tx_bits_to_bytes
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: tx_bytes_to_bits
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: tx_fec_switch_in
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 1 if fec_enabled else 0
    type: byte
  states: {}
- name: tx_fec_switch_out
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 1 if fec_enabled else 0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: tx_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_level
    type: complex
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    name: '"TX spectrum"'
    type: complex
  states: {}

connections:
- [fec_encoder, '0', tx_fec_switch_out, '1']
- [packetizer, '0', tx_bytes_to_bits, '0']
- [qpsk_mod, '0', tx_scale, '0']
- [tx_bits_to_bytes, '0', qpsk_mod, '0']
- [tx_bytes_to_bits, '0', tx_fec_switch_in, '0']
- [tx_fec_switch_in, '0', tx_fec_switch_out, '0']
- [tx_fec_switch_in, '1', fec_encoder, '0']
- [tx_fec_switch_out, '0', tx_bits_to_bytes, '0']
- [tx_scale, '0', pluto_tx, '0']
- [tx_scale, '0', tx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

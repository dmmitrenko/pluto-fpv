options:
  parameters:
    generate_options: qt_gui
    id: fpv_rx
    output_language: python
    title: fpv_rx
  states: {}

blocks:
- name: bitrate_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,2
    label: '''Received bitrate'''
    type: string
    value: bitrate_probe
  states: {}
- name: bitrate_probe
  id: variable_function_probe
  parameters:
    block_id: depacketizer
    function_name: get_bitrate_text
    poll_rate: '4'
    value: '''...'''
  states: {}
- name: cc_decoder
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: fec_k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: fec_poly_list
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: center_freq
  id: variable_config
  parameters:
    config_file: common.ini
    option: center_freq
    section: main
    type: int
    value: '2420000000'
    writeback: None
  states: {}
- name: excess_bw
  id: variable_config
  parameters:
    config_file: common.ini
    option: excess_bw
    section: main
    type: real
    value: '0.35'
    writeback: None
  states: {}
- name: fec_enabled
  id: variable_config
  parameters:
    config_file: common.ini
    option: fec_enabled
    section: main
    type: int
    value: '1'
    writeback: None
  states: {}
- name: fec_k
  id: variable_config
  parameters:
    config_file: common.ini
    option: fec_k
    section: main
    type: int
    value: '7'
    writeback: None
  states: {}
- name: fec_poly_list
  id: variable
  parameters:
    value: '[int(p) for p in fec_polys.split('','')]'
  states: {}
- name: fec_polys
  id: variable_config
  parameters:
    config_file: common.ini
    option: '''fec_polys'''
    section: main
    type: string
    value: 79,109
    writeback: None
  states: {}
- name: log_period_s
  id: variable_config
  parameters:
    config_file: rx.ini
    option: log_period_s
    section: main
    type: real
    value: '1'
    writeback: None
  states: {}
- name: loss_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 3,0,1,2
    label: '''Lost packets'''
    type: string
    value: loss_probe
  states: {}
- name: loss_probe
  id: variable_function_probe
  parameters:
    block_id: depacketizer
    function_name: get_loss_text
    poll_rate: '4'
    value: '''...'''
  states: {}
- name: max_freq_offset_hz
  id: variable_config
  parameters:
    config_file: rx.ini
    option: max_freq_offset_hz
    section: main
    type: real
    value: '200000'
    writeback: None
  states: {}
- name: mode_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 4,0,1,2
    label: '''Modulation'''
    type: string
    value: modulation_text
  states: {}
- name: modulation_text
  id: variable
  parameters:
    value: ('QPSK + CC 1/2, K=%d' % fec_k) if fec_enabled else 'QPSK, FEC off'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pluto_uri
  id: variable_config
  parameters:
    config_file: rx.ini
    option: '''pluto_uri'''
    section: main
    type: string
    value: ip:192.168.2.1
    writeback: None
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: rf_bandwidth
  id: variable_config
  parameters:
    config_file: rx.ini
    option: rf_bandwidth
    section: main
    type: int
    value: '2000000'
    writeback: None
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: rx_gain_cfg
  id: variable_config
  parameters:
    config_file: rx.ini
    option: rx_gain
    section: main
    type: real
    value: '40'
    writeback: None
  states: {}
- name: rx_gain_slider
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: '''RX gain, dB'''
    start: '0'
    step: '1'
    stop: '71'
    value: rx_gain_cfg
  states: {}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: common.ini
    option: samp_rate
    section: main
    type: int
    value: '2000000'
    writeback: None
  states: {}
- name: sps
  id: variable_config
  parameters:
    config_file: common.ini
    option: sps
    section: main
    type: int
    value: '2'
    writeback: None
  states: {}
- name: sync_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,2
    label: '''Sync'''
    type: string
    value: sync_probe
  states: {}
- name: sync_probe
  id: variable_function_probe
  parameters:
    block_id: depacketizer
    function_name: get_sync_text
    poll_rate: '4'
    value: '''...'''
  states: {}
- name: ts_per_frame
  id: variable_config
  parameters:
    config_file: common.ini
    option: ts_per_frame
    section: main
    type: int
    value: '4'
    writeback: None
  states: {}
- name: udp_out_addr
  id: variable_config
  parameters:
    config_file: rx.ini
    option: '''udp_out_addr'''
    section: main
    type: string
    value: 127.0.0.1
    writeback: None
  states: {}
- name: udp_out_port
  id: variable_config
  parameters:
    config_file: rx.ini
    option: udp_out_port
    section: main
    type: int
    value: '5001'
    writeback: None
  states: {}
- name: agc
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: bits_to_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: carrier_coarse
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: 11*sps + 1
    rolloff: excess_bw
    samps_per_sym: sps
    type: cc
    w: '0.0628'
  states: {}
- name: carrier_fine
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: carrier_loop_limits
  id: snippet
  parameters:
    code: |
      # Keep the carrier loops inside the expected frequency offset range.
      # Without the limits they wander over noise while the signal is absent,
      # get stuck at the far end of their range and the link does not recover.
      import math
      limit = 2 * math.pi * self.max_freq_offset_hz / self.samp_rate
      self.carrier_coarse.set_max_freq(limit)
      self.carrier_coarse.set_min_freq(-limit)
      self.carrier_fine.set_max_freq(0.5)
      self.carrier_fine.set_min_freq(-0.5)
    section: main_after_init
  states: {}
- name: clock_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.0628'
    max_dev: '0.02'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: depacketizer
  id: epy_block
  parameters:
    _source_code: |
      """
      FPV Depacketizer (sink block).

      Input: the demodulated and FEC-decoded bit stream (one bit per byte).
      Frame layout (see the packetizer):

          [ sync 32 bit | length 16 bit | length 16 bit | seq 16 bit | type 8 bit | IV 128 bit | AES-CTR(payload + CRC32) | CRC32 ]

      What the block does:
      - frame sync: searches for the sync word, checks the length fields and the
        CRC32; after the first good frame it expects the next frames back to back
        and only returns to searching after several bad frames in a row;
      - removes whitening, checks CRC32, drops damaged frames;
      - sends the payload of data frames to UDP (MPEG-TS for the video player);
      - counts lost frames from gaps in the sequence numbers;
      - tracks sync state, received bitrate and loss ratio for the GUI;
      - writes sync/loss/recovery events to a log file;
      - provides counters for the periodic status line in the log.
      """

      import collections
      import logging
      import os
      import socket
      import threading
      import time
      import zlib

      import numpy as np
      from gnuradio import gr
      # BEGIN embedded modem_crypto.py
      """AES-128-CTR adapted from the supplied OFDM TX/RX embedded blocks.

      Runs inside GNU Radio packetizer/depacketizer, not in the video applications.
      CRC detects accidental damage/wrong keys; CTR is NOT authenticated encryption.
      No replay protection. Both endpoints must use the same embedded key.
      """
      import os
      import zlib
      from Crypto.Cipher import AES

      # Shared secret: keep this module private. Change on both endpoints together.
      KEY = bytes.fromhex("14ddcf63d5b3cc389d4017aee0e9c562")
      CRYPTO_OVERHEAD = 16 + 4  # transmitted counter block + encrypted payload CRC32
      FRAME_OVERHEAD = 15 + CRYPTO_OVERHEAD


      class FrameCipher:
          def __init__(self, key=KEY):
              if len(key) != 16:
                  raise ValueError("AES-128 requires exactly 16 key bytes")
              self.key = key
              self.nonce = os.urandom(12)
              self.counter = 0

          def encrypt(self, payload):
              plain = payload + zlib.crc32(payload).to_bytes(4, "big")
              blocks = (len(plain) + 15) // 16
              if self.counter + blocks > 2**32:
                  raise OverflowError("AES counter exhausted; restart TX for a fresh nonce")
              iv = self.nonce + self.counter.to_bytes(4, "big")
              cipher = AES.new(self.key, AES.MODE_CTR, nonce=self.nonce,
                               initial_value=self.counter)
              self.counter += blocks  # no overlapping counter ranges between frames
              return iv + cipher.encrypt(plain)

          def decrypt(self, record):
              if len(record) < CRYPTO_OVERHEAD:
                  raise ValueError("Truncated AES frame")
              iv = record[:16]
              cipher = AES.new(self.key, AES.MODE_CTR, nonce=iv[:12],
                               initial_value=int.from_bytes(iv[12:], "big"))
              plain = cipher.decrypt(record[16:])
              if zlib.crc32(plain[:-4]).to_bytes(4, "big") != plain[-4:]:
                  raise ValueError("AES plaintext CRC mismatch (wrong key or damaged frame)")
              return plain[:-4]

      # END embedded modem_crypto.py

      # Log files go to logs/<yyyy-mm-dd>/ in the repository root (next to src), one
      # folder per day. video_common.py and tx_modem_loop.sh use the same place.
      def log_path(name):
          folder = os.path.join(os.path.dirname(os.path.dirname(os.path.abspath(__file__))),
                                "logs", time.strftime("%Y-%m-%d"))
          os.makedirs(folder, exist_ok=True)
          return os.path.join(folder, name)


      TS_PACKET_LEN = 188
      SYNC_WORD = bytes([0xE1, 0x5A, 0xE8, 0x93])
      HEADER_LEN = 8
      FRAME_TYPE_DATA = 1
      # Bit errors tolerated in the 32-bit sync word while searching.
      SYNC_MAX_ERRORS = 2
      # Bad frames in a row before frame sync is declared lost.
      MAX_BAD_FRAMES = 4
      # No good frame for this long means the link is considered lost.
      SYNC_TIMEOUT_S = 0.5
      # Window for the bitrate and loss figures shown in the GUI.
      STATS_WINDOW_S = 2.0
      # A jump this large in sequence numbers is a transmitter restart, not loss.
      MAX_PLAUSIBLE_GAP = 2000


      def whitening_sequence(length):
          """Pseudo-random bytes from the LFSR x^7 + x^4 + 1, all-ones start."""
          state = 0x7F
          out = bytearray(length)
          for i in range(length):
              value = 0
              for _ in range(8):
                  bit = ((state >> 6) ^ (state >> 3)) & 1
                  state = ((state << 1) | bit) & 0x7F
                  value = (value << 1) | bit
              out[i] = value
          return np.frombuffer(bytes(out), dtype=np.uint8)


      class blk(gr.sync_block):
          def __init__(self, udp_addr="127.0.0.1", udp_port=5001, ts_per_frame=4,
                       log_file="rx.log"):
              gr.sync_block.__init__(
                  self, name="FPV Depacketizer + AES-128 RX", in_sig=[np.uint8], out_sig=None
              )
              self.udp_addr = udp_addr
              self.udp_port = int(udp_port)
              self.payload_len = TS_PACKET_LEN * int(ts_per_frame)
              self.body_len = 3 + self.payload_len + CRYPTO_OVERHEAD + 4
              self._cipher = FrameCipher()
              self.frame_bits = (HEADER_LEN + self.body_len) * 8
              self.log_file = log_file

              self._whitening = whitening_sequence(self.body_len)
              sync_bits = np.unpackbits(np.frombuffer(SYNC_WORD, dtype=np.uint8))
              # +1/-1 form: the correlation peak equals 32 minus twice the bit errors.
              self._sync_pattern = sync_bits.astype(np.float32) * 2 - 1
              self._sync_threshold = 32 - 2 * SYNC_MAX_ERRORS

              self._lock = threading.Lock()
              self._sock = None
              self._log = logging.getLogger("fpv_rx")
              self._bits = np.zeros(0, dtype=np.uint8)
              self._frame_locked = False
              self._bad_frames = 0
              self._last_seq = None
              self._last_good_time = None
              self._lost_since = None
              self._in_sync = False
              # (time, frames received, frames lost, payload bytes delivered)
              self._history = collections.deque()
              self._total_received = 0
              self._total_lost = 0
              self._total_crc_errors = 0
              self._crypto_errors = 0
              self._sync_losses = 0
              self._sync_hits = 0
              self._last_recovery_s = 0.0
              # Set while the flow graph is not running; ends the status thread.
              self.stopped = threading.Event()
              self.stopped.set()

          # The socket and the log are opened in start(), not in __init__, because
          # GNU Radio Companion creates the block once just to inspect its ports.
          def start(self):
              self._log.setLevel(logging.INFO)
              if self.log_file and not self._log.handlers:
                  handler = logging.FileHandler(log_path(self.log_file))
                  handler.setFormatter(logging.Formatter("%(asctime)s %(levelname)s %(message)s"))
                  self._log.addHandler(handler)
              self._sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self._log.info(
                  "start: udp=%s:%d frame_bytes=%d",
                  self.udp_addr, self.udp_port, self.frame_bits // 8,
              )
              self._log.info("AES-128-CTR enabled in modem; crypto overhead %d bytes/frame", CRYPTO_OVERHEAD)
              self.stopped.clear()
              return True

          def stop(self):
              self.stopped.set()
              if self._sock is not None:
                  self._sock.close()
                  self._sock = None
              self._log.info(
                  "stop: received=%d lost=%d crc_errors=%d sync_losses=%d",
                  self._total_received, self._total_lost, self._total_crc_errors,
                  self._sync_losses,
              )
              for handler in list(self._log.handlers):
                  handler.close()
                  self._log.removeHandler(handler)
              return True

          # ---- values for the GUI (polled by Function Probe blocks) ----

          def get_sync(self):
              with self._lock:
                  self._update_sync(time.monotonic())
                  return self._in_sync

          def get_sync_text(self):
              return "LOCKED" if self.get_sync() else "NO SYNC"

          def get_bitrate_kbps(self):
              with self._lock:
                  self._trim_history(time.monotonic())
                  payload_bytes = sum(item[3] for item in self._history)
                  return payload_bytes * 8 / STATS_WINDOW_S / 1000.0

          def get_loss_percent(self):
              with self._lock:
                  self._trim_history(time.monotonic())
                  received = sum(item[1] for item in self._history)
                  lost = sum(item[2] for item in self._history)
                  if received + lost == 0:
                      return 0.0
                  return 100.0 * lost / (received + lost)

          def get_bitrate_text(self):
              return "%.0f kbit/s" % self.get_bitrate_kbps()

          def get_loss_text(self):
              return "%.1f %% (total lost: %d)" % (self.get_loss_percent(), self._total_lost)

          def get_total_received(self):
              return self._total_received

          def get_total_lost(self):
              return self._total_lost

          def get_total_crc_errors(self):
              return self._total_crc_errors

          def get_sync_losses(self):
              return self._sync_losses

          def get_last_recovery_ms(self):
              return self._last_recovery_s * 1000.0

          def get_totals(self):
              """Counters since the start, for the status line in the log."""
              with self._lock:
                  return dict(
                      received=self._total_received,
                      lost=self._total_lost,
                      crc_errors=self._total_crc_errors,
                      sync_hits=self._sync_hits,
                  )

          # ---- statistics and link state ----

          def _trim_history(self, now):
              while self._history and now - self._history[0][0] > STATS_WINDOW_S:
                  self._history.popleft()

          def _update_sync(self, now):
              alive = (
                  self._last_good_time is not None
                  and now - self._last_good_time < SYNC_TIMEOUT_S
              )
              if alive and not self._in_sync:
                  self._in_sync = True
                  if self._lost_since is None:
                      self._log.info("sync acquired")
                  else:
                      self._last_recovery_s = now - self._lost_since
                      self._log.info(
                          "sync recovered after %.0f ms without frames",
                          self._last_recovery_s * 1000.0,
                      )
              elif not alive and self._in_sync:
                  self._in_sync = False
                  self._sync_losses += 1
                  self._lost_since = self._last_good_time
                  self._log.warning("sync lost")

          def _handle_frame(self, body, now):
              seq = (body[0] << 8) | body[1]
              frame_type = body[2]

              lost = 0
              if self._last_seq is not None:
                  gap = (seq - self._last_seq - 1) & 0xFFFF
                  if gap > MAX_PLAUSIBLE_GAP:
                      self._log.info("sequence jump %d -> %d, transmitter restarted", self._last_seq, seq)
                  elif gap > 0:
                      lost = gap
                      self._log.warning("lost %d frame(s) before seq %d", gap, seq)
              self._last_seq = seq

              delivered = 0
              if frame_type == FRAME_TYPE_DATA:
                  payload = body[3:3 + self.payload_len]
                  try:
                      self._sock.sendto(payload, (self.udp_addr, self.udp_port))
                      delivered = len(payload)
                  except OSError as error:
                      self._log.error("udp send failed: %s", error)

              self._total_received += 1
              self._total_lost += lost
              self._last_good_time = now
              self._history.append((now, 1, lost, delivered))
              self._update_sync(now)

          # ---- frame sync ----

          def _decode(self, frame_bits, strict_header):
              """Returns the frame body if the frame is valid, otherwise None."""
              data = np.packbits(frame_bits)
              if strict_header:
                  # While searching, a candidate must carry the right length in at
                  # least one of the two copies; this rejects most false sync hits.
                  first = (int(data[4]) << 8) | int(data[5])
                  second = (int(data[6]) << 8) | int(data[7])
                  if first != self.body_len and second != self.body_len:
                      return None
              body = (data[HEADER_LEN:] ^ self._whitening).tobytes()
              if zlib.crc32(body[:-4]).to_bytes(4, "big") != body[-4:]:
                  return None
              try:
                  payload = self._cipher.decrypt(body[3:-4])
              except (ValueError, OverflowError):
                  self._crypto_errors += 1
                  if self._crypto_errors == 1 or self._crypto_errors % 1000 == 0:
                      self._log.warning("AES decrypt/CRC failures: %d; check shared modem key", self._crypto_errors)
                  return None
              return body[:3] + payload + body[-4:]

          def _search(self, now):
              """Looks for a valid frame anywhere in the buffer. True if one was found."""
              last_start = len(self._bits) - self.frame_bits
              if last_start < 0:
                  return False
              window = self._bits[:last_start + 32].astype(np.float32) * 2 - 1
              score = np.correlate(window, self._sync_pattern, mode="valid")
              for start in np.flatnonzero(score >= self._sync_threshold):
                  # Counted even if the frame turns out damaged: many hits without
                  # good frames mean the signal is demodulated but too noisy.
                  self._sync_hits += 1
                  body = self._decode(self._bits[start:start + self.frame_bits], True)
                  if body is not None:
                      self._bits = self._bits[start + self.frame_bits:]
                      self._frame_locked = True
                      self._bad_frames = 0
                      self._log.info("frame sync found")
                      self._handle_frame(body, now)
                      return True
              # Nothing valid: keep only the tail that could not be checked yet.
              self._bits = self._bits[last_start + 1:]
              return False

          def _track(self, now):
              """Takes the next frame at the expected position. False if more bits are needed."""
              if len(self._bits) < self.frame_bits:
                  return False
              body = self._decode(self._bits[:self.frame_bits], False)
              if body is not None:
                  self._bits = self._bits[self.frame_bits:]
                  self._bad_frames = 0
                  self._handle_frame(body, now)
                  return True
              self._total_crc_errors += 1
              self._bad_frames += 1
              if self._bad_frames >= MAX_BAD_FRAMES:
                  # The bit position may have slipped; search again from here.
                  self._frame_locked = False
                  self._log.warning("frame sync lost after %d bad frames", self._bad_frames)
              else:
                  self._bits = self._bits[self.frame_bits:]
              return True

          def work(self, input_items, output_items):
              data = input_items[0]
              now = time.monotonic()
              with self._lock:
                  self._bits = np.concatenate((self._bits, data & 1))
                  while True:
                      if self._frame_locked:
                          if not self._track(now):
                              break
                      elif not self._search(now):
                          break
                  self._update_sync(now)
              return len(data)
    log_file: '''rx.log'''
    ts_per_frame: ts_per_frame
    udp_addr: udp_out_addr
    udp_port: udp_out_port
  states: {}
- name: diff_decoder
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: fec_decoder
  id: fec_extended_decoder
  parameters:
    decoder_list: cc_decoder
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: link_monitor
  id: snippet
  parameters:
    code: |
      # Writes the settings and, once per log period, the state of the link to
      # rx.log. The values are only read from the blocks, nothing is changed.
      import logging
      import math
      import threading
      import time

      import numpy as np

      # Snapshots of the signal taken from the probes during one log period.
      SNAPSHOTS = 10
      # Full scale of the radio is 1.0. A sample this close to it counts as clipped.
      CLIP_LEVEL = 0.98
      # Written when there was nothing to measure.
      NO_SIGNAL_DB = -200.0

      log = logging.getLogger("fpv_rx")
      log.info(
          "settings: center_freq=%d samp_rate=%d sps=%d excess_bw=%.2f ts_per_frame=%d "
          "fec_enabled=%d fec_k=%d fec_polys=%s pluto_uri=%s rf_bandwidth=%d rx_gain=%.0f "
          "max_freq_offset_hz=%.0f log_period_s=%.1f",
          self.center_freq, self.samp_rate, self.sps, self.excess_bw, self.ts_per_frame,
          self.fec_enabled, self.fec_k, self.fec_polys, self.pluto_uri, self.rf_bandwidth,
          self.rx_gain_slider, self.max_freq_offset_hz, self.log_period_s,
      )

      def to_db(ratio):
          return 10 * math.log10(ratio) if ratio > 0 and math.isfinite(ratio) else NO_SIGNAL_DB

      def report_loop():
          depacketizer = self.depacketizer
          totals = depacketizer.get_totals()
          samples = self.pluto_rx.nitems_written(0)
          last_time = time.monotonic()
          while True:
              measured = clipped = 0
              power = peak = ideal_power = error_power = 0.0
              for _ in range(SNAPSHOTS):
                  # stopped is set when the flow graph stops, which ends this thread.
                  if depacketizer.stopped.wait(self.log_period_s / SNAPSHOTS):
                      return
                  # Signal as it comes from the radio.
                  data = np.array(self.rx_input_probe.level())
                  largest = np.maximum(np.abs(data.real), np.abs(data.imag))
                  measured += len(data)
                  power += float(np.vdot(data, data).real)
                  peak = max(peak, float(largest.max()))
                  clipped += int(np.count_nonzero(largest >= CLIP_LEVEL))
                  # Recovered symbols against the four QPSK points, which lie on the
                  # diagonals at the mean amplitude.
                  symbols = np.array(self.rx_symbol_probe.level())
                  amplitude = float(np.mean(np.abs(symbols)))
                  points = (np.sign(symbols.real) + 1j * np.sign(symbols.imag)) * amplitude / math.sqrt(2)
                  ideal_power += amplitude * amplitude * len(symbols)
                  error_power += float(np.vdot(symbols - points, symbols - points).real)

              now = time.monotonic()
              elapsed = now - last_time
              last_time = now
              previous, previous_samples = totals, samples
              totals = depacketizer.get_totals()
              samples = self.pluto_rx.nitems_written(0)
              # The loops report the correction they apply. The coarse loop runs at
              # the sample rate and with the opposite sign, the fine loop at the
              # symbol rate. Their sum is the frequency offset of the transmitter.
              symbol_rate = self.samp_rate / float(self.sps)
              coarse_hz = -self.carrier_coarse.get_frequency() * self.samp_rate / (2 * math.pi)
              fine_hz = self.carrier_fine.get_frequency() * symbol_rate / (2 * math.pi)
              log.info(
                  "status: sync=%d samples=%.3f level_dbfs=%.1f peak=%.2f clipped=%.2f%% "
                  "rx_gain=%.0f agc_gain=%.1f freq_offset_hz=%.0f coarse_hz=%.0f fine_hz=%.0f "
                  "clock_rate=%.5f mer_db=%.1f frames=%d lost=%d crc_errors=%d sync_hits=%d "
                  "kbit=%.0f",
                  depacketizer.get_sync(),
                  (samples - previous_samples) / (elapsed * self.samp_rate),
                  to_db(power / measured), peak, 100.0 * clipped / measured,
                  self.rx_gain_slider, self.agc.gain(),
                  coarse_hz + fine_hz, coarse_hz, fine_hz,
                  self.clock_sync.clock_rate(),
                  to_db(ideal_power / error_power) if error_power > 0 else NO_SIGNAL_DB,
                  totals["received"] - previous["received"],
                  totals["lost"] - previous["lost"],
                  totals["crc_errors"] - previous["crc_errors"],
                  totals["sync_hits"] - previous["sync_hits"],
                  depacketizer.get_bitrate_kbps(),
              )

      if self.log_period_s > 0:
          threading.Thread(target=report_loop, daemon=True).start()
    section: main_after_start
  states: {}
- name: pluto_rx
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    manual_gain1: rx_gain_slider
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_uri
  states: {}
- name: rx_constellation
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 5,1,1,1
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: rx_fec_switch_in
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: 1 if fec_enabled else 0
    type: byte
  states: {}
- name: rx_fec_switch_out
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: 1 if fec_enabled else 0
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: rx_input_probe
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '4096'
  states: {}
- name: rx_input_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 5,0,1,1
    name: '"RX spectrum"'
    type: complex
  states: {}
- name: rx_symbol_probe
  id: blocks_probe_signal_vx
  parameters:
    type: complex
    vlen: '4096'
  states: {}
- name: rx_symbol_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: complex
  states: {}
- name: soft_offset
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: soft_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: symbol_decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: symbol_map
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: symbols_to_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: clip_split
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: clip_i
  id: analog_rail_ff
  parameters:
    hi: '2.0'
    lo: '-2.0'
  states: {}
- name: clip_q
  id: analog_rail_ff
  parameters:
    hi: '2.0'
    lo: '-2.0'
  states: {}
- name: clip_join
  id: blocks_float_to_complex
  parameters: {}
  states: {}

connections:
- [agc, '0', clip_split, '0']
- [clip_split, '0', clip_i, '0']
- [clip_split, '1', clip_q, '0']
- [clip_i, '0', clip_join, '0']
- [clip_q, '0', clip_join, '1']
- [clip_join, '0', carrier_coarse, '0']
- [bits_to_float, '0', soft_scale, '0']
- [carrier_coarse, '0', clock_sync, '0']
- [carrier_fine, '0', rx_constellation, '0']
- [carrier_fine, '0', rx_symbol_vector, '0']
- [carrier_fine, '0', symbol_decoder, '0']
- [clock_sync, '0', carrier_fine, '0']
- [diff_decoder, '0', symbol_map, '0']
- [fec_decoder, '0', rx_fec_switch_out, '1']
- [pluto_rx, '0', agc, '0']
- [pluto_rx, '0', rx_input_vector, '0']
- [pluto_rx, '0', rx_spectrum, '0']
- [rx_fec_switch_in, '0', rx_fec_switch_out, '0']
- [rx_fec_switch_in, '1', bits_to_float, '0']
- [rx_fec_switch_out, '0', depacketizer, '0']
- [rx_input_vector, '0', rx_input_probe, '0']
- [rx_symbol_vector, '0', rx_symbol_probe, '0']
- [soft_offset, '0', fec_decoder, '0']
- [soft_scale, '0', soft_offset, '0']
- [symbol_decoder, '0', diff_decoder, '0']
- [symbol_map, '0', symbols_to_bits, '0']
- [symbols_to_bits, '0', rx_fec_switch_in, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
